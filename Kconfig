## Kconfig
```kconfig
mainmenu "FiBot Configuration"

source "projects/$(PROJECT)/Kconfig"
source "yard/Kconfig"
```
